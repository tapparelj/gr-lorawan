options:
  parameters:
    author: Tapparel Joachim@EPFL,TCL
    generate_options: no_gui
    id: lorawan_tx
    output_language: python
  states: {}

blocks:
- name: cr
  id: variable
  parameters:
    value: '1'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: lora_sdr_add_crc_0
  id: lora_sdr_add_crc
  parameters:
    has_crc: has_crc
  states: {}
- name: lora_sdr_gray_demap_0
  id: lora_sdr_gray_demap
  parameters:
    sf: '7'
  states: {}
- name: lora_sdr_hamming_enc_0
  id: lora_sdr_hamming_enc
  parameters:
    cr: cr
    sf: '7'
  states: {}
- name: lora_sdr_header_0
  id: lora_sdr_header
  parameters:
    cr: cr
    has_crc: has_crc
    impl_head: impl_head
  states: {}
- name: lora_sdr_interleaver_0
  id: lora_sdr_interleaver
  parameters:
    bw: '125000'
    cr: cr
    ldro: '2'
    sf: '7'
  states: {}
- name: lora_sdr_modulate_0
  id: lora_sdr_modulate
  parameters:
    bw: '125000'
    frame_zero_padd: int(80*2**7)
    minoutbuf: '10000000'
    preamb_len: '8'
    samp_rate: '250000'
    sf: '7'
    sync_words: '[0x34]'
  states: {}
- name: lora_sdr_whitening_0
  id: lora_sdr_whitening
  parameters:
    is_hex: 'True'
    length_tag_name: '''packet_len'''
    separator: ''','''
    source_type: message_strobe
    use_length_tag: 'False'
  states: {}
- name: lorawan_lorawan_source_0
  id: lorawan_lorawan_source
  parameters:
    tcp_port: '12345'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: '125000'
    center_freq0: 868.1e6
    clock_rate: '0.0'
    dev_addr: '"addr=192.168.10.2"'
    gain0: '0'
    len_tag_name: frame_len
    samp_rate: '250000'
    sync: none
    type: fc32
  states: {}

connections:
- [lora_sdr_add_crc_0, '0', lora_sdr_hamming_enc_0, '0']
- [lora_sdr_gray_demap_0, '0', lora_sdr_modulate_0, '0']
- [lora_sdr_hamming_enc_0, '0', lora_sdr_interleaver_0, '0']
- [lora_sdr_header_0, '0', lora_sdr_add_crc_0, '0']
- [lora_sdr_interleaver_0, '0', lora_sdr_gray_demap_0, '0']
- [lora_sdr_modulate_0, '0', uhd_usrp_sink_0, '0']
- [lora_sdr_whitening_0, '0', lora_sdr_header_0, '0']
- [lorawan_lorawan_source_0, command, uhd_usrp_sink_0, command]
- [lorawan_lorawan_source_0, dict, lora_sdr_whitening_0, dict]
- [lorawan_lorawan_source_0, out0, lora_sdr_whitening_0, msg]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-604-gd7f88722
